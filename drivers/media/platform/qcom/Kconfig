## drivers/media/platform/qcom/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0-only

comment "Qualcomm media platform drivers"

source "drivers/media/platform/qcom/camss/Kconfig"
```
